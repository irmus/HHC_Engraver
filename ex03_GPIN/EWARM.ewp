# IAR project EWARM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F429_439xx; USE_STDPERIPH_DRIVER; TARGET_STM32F4XX=1
  ICCARM.CCIncludePath2: ..\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\drv
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: EWARM.out
  ILINK.IlinkIcfFile: ..\drv\stm32f429xI.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group drv
    ../drv/: assert.c led.c startup_stm32f429_439xx.s switch.c system_stm32f4xx.c util.c
  group lib
    ../Libraries/STM32F4xx_StdPeriph_Driver/Debug/Exe/: STM32F4_StdPeriph_Driver.a
  group src
    ./: main.c
